#include "nivona_crypto.h"

const uint8_t NIVONA_RC4_KEY[NIVONA_RC4_KEY_LEN] = {
    'N','I','V','_','0','6','0','6','1','6','_','V','1','0','_','1',
    '*','9','#','3','!','4','$','6','+','4','r','e','s','-','?','3'
};

const uint8_t NIVONA_HU_TABLE[256] = {
    0x62,0x06,0x55,0x96,0x24,0x17,0x70,0xA4,0x87,0xCF,0xA9,0x05,0x1A,0x40,0xA5,0xDB,
    0x3D,0x14,0x44,0x59,0x82,0x3F,0x34,0x66,0x18,0xE5,0x84,0xF5,0x50,0xD8,0xC3,0x73,
    0x5A,0xA8,0x9C,0xCB,0xB1,0x78,0x02,0xBE,0xBC,0x07,0x64,0xB9,0xAE,0xF3,0xA2,0x0A,
    0xED,0x12,0xFD,0xE1,0x08,0xD0,0xAC,0xF4,0xFF,0x7E,0x65,0x4F,0x91,0xEB,0xE4,0x79,
    0x7B,0xFB,0x43,0xFA,0xA1,0x00,0x6B,0x61,0xF1,0x6F,0xB5,0x52,0xF9,0x21,0x45,0x37,
    0x3B,0x99,0x1D,0x09,0xD5,0xA7,0x54,0x5D,0x1E,0x2E,0x5E,0x4B,0x97,0x72,0x49,0xDE,
    0xC5,0x60,0xD2,0x2D,0x10,0xE3,0xF8,0xCA,0x33,0x98,0xFC,0x7D,0x51,0xCE,0xD7,0xBA,
    0x27,0x9E,0xB2,0xBB,0x83,0x88,0x01,0x31,0x32,0x11,0x8D,0x5B,0x2F,0x81,0x3C,0x63,
    0x9A,0x23,0x56,0xAB,0x69,0x22,0x26,0xC8,0x93,0x3A,0x4D,0x76,0xAD,0xF6,0x4C,0xFE,
    0x85,0xE8,0xC4,0x90,0xC6,0x7C,0x35,0x04,0x6C,0x4A,0xDF,0xEA,0x86,0xE6,0x9D,0x8B,
    0xBD,0xCD,0xC7,0x80,0xB0,0x13,0xD3,0xEC,0x7F,0xC0,0xE7,0x46,0xE9,0x58,0x92,0x2C,
    0xB7,0xC9,0x16,0x53,0x0D,0xD6,0x74,0x6D,0x9F,0x20,0x5F,0xE2,0x8C,0xDC,0x39,0x0C,
    0xDD,0x1F,0xD1,0xB6,0x8F,0x5C,0x95,0xB8,0x94,0x3E,0x71,0x41,0x25,0x1B,0x6A,0xA6,
    0x03,0x0E,0xCC,0x48,0x15,0x29,0x38,0x42,0x1C,0xC1,0x28,0xD9,0x19,0x36,0xB3,0x75,
    0xEE,0x57,0xF0,0x9B,0xB4,0xAA,0xF2,0xD4,0xBF,0xA3,0x4E,0xDA,0x89,0xC2,0xAF,0x6E,
    0x2B,0x77,0xE0,0x47,0x7A,0x8E,0x2A,0xA0,0x68,0x30,0xF7,0x67,0x0F,0x0B,0x8A,0xEF,
};

void nivona_rc4(const uint8_t *key, size_t key_len,
                const uint8_t *in, uint8_t *out, size_t len) {
    uint8_t s[256];
    for (int i = 0; i < 256; i++) s[i] = (uint8_t)i;
    uint8_t j = 0;
    for (int i = 0; i < 256; i++) {
        j = (uint8_t)(j + s[i] + key[i % key_len]);
        uint8_t t = s[i]; s[i] = s[j]; s[j] = t;
    }
    uint8_t ii = 0, jj = 0;
    for (size_t k = 0; k < len; k++) {
        ii = (uint8_t)(ii + 1);
        jj = (uint8_t)(jj + s[ii]);
        uint8_t t = s[ii]; s[ii] = s[jj]; s[jj] = t;
        out[k] = in[k] ^ s[(uint8_t)(s[ii] + s[jj])];
    }
}

void nivona_hu_verifier(const uint8_t *buf, size_t start, size_t count,
                        uint8_t out[2]) {
    uint8_t s = NIVONA_HU_TABLE[buf[start]];
    for (size_t i = start + 1; i < start + count; i++) {
        s = NIVONA_HU_TABLE[s ^ buf[i]];
    }
    out[0] = (uint8_t)(s + 0x5D);

    s = NIVONA_HU_TABLE[(uint8_t)(buf[start] + 1)];
    for (size_t i = start + 1; i < start + count; i++) {
        s = NIVONA_HU_TABLE[s ^ buf[i]];
    }
    out[1] = (uint8_t)(s + 0xA7);
}
